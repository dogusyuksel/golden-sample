DESCRIPTION = "HAL GPIO Example"
SECTION = "hal"
LICENSE = "CLOSED"

PV = "1.0.0"
PR = "basic"
NAME = "GPIO"

PATCH_FILE = "/workspace/hal/patches/gpio.patch"
