DESCRIPTION = "HAL ADC DMA Example"
SECTION = "hal"
LICENSE = "CLOSED"

PV = "1.0.0"
PR = "basic"
NAME = "ADC-DMA"

PATCH_FILE = "/workspace/hal/patches/adcdma.patch"
