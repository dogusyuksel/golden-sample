DESCRIPTION = "HAL UART RTC Example"
SECTION = "hal"
LICENSE = "CLOSED"

PV = "1.0.0"
PR = "basic"
NAME = "UART-RTC"

PATCH_FILE = "/workspace/hal/patches/uartrtc.patch"
